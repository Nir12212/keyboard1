## boards/shields/magickeyboard/Kconfig.defconfig
```kconfig
if SHIELD_MAGICKEYBOARD

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "magicKeyboard"

endif
```
